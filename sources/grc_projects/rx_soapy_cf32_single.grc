options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: test_complex
    output_language: python
    title: open.space testing
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: '1'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    antenna0: RX
    center_freq0: 5.6e9
    driver: mipi
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: 5.6e9
    dc_removal0: 'False'
    driver: mipi
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
