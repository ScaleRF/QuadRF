options:
  parameters:
    generate_options: qt_gui
    id: test_complex
    output_language: python
    title: open.space testing
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '73591639'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: 7e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_1
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/dsi_stream0
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4'
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '4'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '3'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '2'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '1'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: 5.6e9
    dc_removal0: 'False'
    driver: mipi
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_interleaved_char_1, '0']
- [blocks_complex_to_interleaved_char_1, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_streams_0, '2', qtgui_freq_sink_x_0_1, '0']
- [blocks_vector_to_streams_0, '3', qtgui_freq_sink_x_0_2, '0']
- [soapy_custom_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
