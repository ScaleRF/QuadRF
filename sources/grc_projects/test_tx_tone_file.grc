options:
  parameters:
    generate_options: qt_gui
    id: test_complex
    output_language: python
    title: open.space testing
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '43130880'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: 7e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_3
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_4
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_5
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_interleaved_char_1
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/dsi_stream0
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/csi_stream0
    minoutbuf: '4096'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '8'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '4'
    type: complex
    update_time: '0.05'
    ymax: '30'
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '3'
    type: complex
    update_time: '0.05'
    ymax: '30'
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '2'
    type: complex
    update_time: '0.05'
    ymax: '30'
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: 18.3975e6
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '1'
    type: complex
    update_time: '0.05'
    ymax: '30'
    ymin: '-60'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_interleaved_char_1, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_char_to_float_0_0_1, '0', blocks_float_to_complex_0_0, '1']
- [blocks_char_to_float_0_0_2, '0', blocks_float_to_complex_0_1, '0']
- [blocks_char_to_float_0_0_3, '0', blocks_float_to_complex_0_1, '1']
- [blocks_char_to_float_0_0_4, '0', blocks_float_to_complex_0_2, '0']
- [blocks_char_to_float_0_0_5, '0', blocks_float_to_complex_0_2, '1']
- [blocks_complex_to_interleaved_char_1, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_float_to_complex_0_1, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_float_to_complex_0_2, '0', qtgui_freq_sink_x_0_2, '0']
- [blocks_stream_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_char_to_float_0_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_char_to_float_0_0_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_char_to_float_0_0_1, '0']
- [blocks_vector_to_streams_0, '4', blocks_char_to_float_0_0_2, '0']
- [blocks_vector_to_streams_0, '5', blocks_char_to_float_0_0_3, '0']
- [blocks_vector_to_streams_0, '6', blocks_char_to_float_0_0_4, '0']
- [blocks_vector_to_streams_0, '7', blocks_char_to_float_0_0_5, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
