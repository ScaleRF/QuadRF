options:
  parameters:
    generate_options: qt_gui
    id: quadrf_block_source_test_multi
    output_language: python
    title: QuadRF RX Spectrum (2 ch)
  states: {}

blocks:
- name: rxgain
  id: variable_qtgui_dial_control
  parameters:
    label: rx gain
    maximum: '63'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: '1'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: '2'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: soapy_quadrf_source_0
  id: soapy_quadrf_source
  parameters:
    agc: 'False'
    agc_setpoint: '-15'
    ant1: 'True'
    ant2: 'True'
    autosteer: 'False'
    bandwidth: '0'
    center_freq: 5.6e9
    dev_args: ''
    gain: rxgain
    nchan: '2'
    phase1: '0'
    phase2: '0'
    pol: rhcp
    samp_rate: samp_rate
    tone_en: 'False'
    tone_freq: 1.0e6
    type: fc32
  states: {}

connections:
- [soapy_quadrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_quadrf_source_0, '1', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
